FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Revert-sunxi-dram-h6-Improve-DDR3-config-detection.patch"
SRC_URI += "file://increase_bootm_len.patch"
