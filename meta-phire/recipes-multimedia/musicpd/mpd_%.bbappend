PACKAGECONFIG:append = " id3tag smb"
PACKAGECONFIG:remove = "ffmpeg"
